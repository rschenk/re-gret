## firmware/zmk/config/boards/shields/regret/Kconfig.shield
```kconfig
config SHIELD_REGRET
    def_bool $(shields_list_contains,regret)
    select SPI
```
